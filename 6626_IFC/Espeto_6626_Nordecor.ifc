Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-10-02T14:10:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 02 14:10:14 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\edc33bf0-6bf4-47ac-9c65-a882836d9e99\587db3f0-f2d8-4700-90d2-aeff7dd00dce\ifc * Database version: 5507 * Database creation date: Thu Oct 02 14:10:11 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 02 14:10:11 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 02 14:10:11 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_330816
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 6626, Espeto_6626_Nordecor_IFC:6626:330816
In: Nível 1
Type - Material: Plástico - Transparente, Metal - Alumínio - Preto, LED, Metal - Alumínio - Anodizado
Type - Cotas - Altura espeto: 250 mm; Diâmetro projetor: 42 mm
Type - Dados - Data de atualização: 02/10/2025; Versão: 1
Type - Dados de identidade - Código Uniformat: D5020.20; Comentários de tipos: espeto de jardim, LED, 3W, 2700K, 24º, iluminação externa, acabamento preto, paisagismo; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Espeto de jardim OYNE acabamento preto, LED 3W 2.700K 24º; Descrição UniFormat: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 66; Localização: Itajaí/SC - Brasil; Modelo: 6626; Nome do tipo: 6626; Nota-chave: 26 56 36.23; Número MasterFormat: 26 56 36; Número OmniClass: 23.80.70.14.14; Tipo de imagem: Imagem raster: 6626.png; Tipo de luminária: Distribuição Direcional / Facho concentrado (24º); Título MasterFormat: Luminárias de Paisagismo; Título OmniClass: Exterior Floodlights; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/espeto-led-oyne-3w-2-700k-irc97/
Type - Elétrico - Comentários de voltagem: 100-240V; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente: 0 W
Type - Engenharia elétrica - Fator de potência da luminária: 1; Voltagem da Luminária: 127 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Fluxo luminoso: 223 lm; IRC: 97; Potência: 3 W; Temperatura da cor: 2700 K; UGR: 13
Type - Materiais e acabamentos - Difusor: Plástico - Transparente; Espeto: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Nome da família: Espeto_6626_Nordecor_IFC
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6626; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Altura colocação do espeto: 320 mm; Altura do espeto: 320 mm; Área: 0.0182339 m2; Inclinação do projetor: 90 deg; Rotação do projetor: 90 deg; Volume: 0.0000859679 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 127 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Espeto_6626_Nordecor_IFC: 6626; Família e tipo: Espeto_6626_Nordecor_IFC: 6626; ID de tipo: Espeto_6626_Nordecor_IFC: 6626; Tipo: Espeto_6626_Nordecor_IFC: 6626
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
